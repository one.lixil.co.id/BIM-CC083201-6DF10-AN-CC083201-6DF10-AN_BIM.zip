Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-04-24T09:46:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Alternate UI 19.0.0.405
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 24 09:46:12 2023 * Host: DESKTOP-6FF1F60 * Database: C:\Users\Artec89\AppData\Local\Temp\{5DE3D4C2-BD46-4E5C-9C1E-71DD10181029}\ifc * Database version: 5507 * Database creation date: Mon Apr 24 09:46:12 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Apr 24 09:46:12 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Apr 24 09:46:12 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowTerminal: S400 CC toilet full set, R305, Asia, CC083201-6DF10-AN_REVIT:S400 CC toilet full set, R305, Asia:347981
In: Level 1
Material: Vitreous China
Pset_DistributionFlowElementCommon - Reference: S400 CC toilet full set, R305, Asia
